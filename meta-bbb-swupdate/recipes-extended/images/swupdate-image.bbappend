IMAGE_FSTYPES = "cpio.gz.u-boot"
IMAGE_INSTALL:append = " init-ifupdown"
