FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://cpts.cfg"
